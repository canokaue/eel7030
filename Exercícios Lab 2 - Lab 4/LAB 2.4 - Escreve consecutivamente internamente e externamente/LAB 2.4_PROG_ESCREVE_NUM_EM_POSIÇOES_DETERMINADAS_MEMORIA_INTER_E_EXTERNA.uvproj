# Keil uVision project LAB 2.4_PROG_ESCREVE_NUM_EM_POSIÇOES_DETERMINADAS_MEMORIA_INTER_E_EXTERNA.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: LAB 2.4_PROG_ESCREVE_NUM_EM_POSIÇOES_DETERMINADAS_MEMORIA_INTER_E_EXTERNA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LAB 2.4_PROG_ESCREVE_NUM_EM_POSIÇOES_DETERMINADAS_MEMORIA_INTER_E_EXTERNA.ASM

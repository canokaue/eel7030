# Keil uVision project LAB 3.3_CONTA_DECRESCENTE_COM_ATRASO_SUB_ROTINA.uvproj, settings and files
target Target 1 (MCS-51)
  device: 8051AH Intel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(12000000)
  output: LAB 3.3_CONTA_DECRESCENTE_COM_ATRASO_SUB_ROTINA +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: LAB 3.3_CONTA_DECRESCENTE_COM_ATRASO_SUB_ROTINA.asm

;Programa MOSTRA1.asm
CS EQU P0.7
END0 EQU P3.3;
END1 EQU P3.4;
ORG 0h
SETB END0
CLR END1
SETB CS
LER: MOV A, P2
CPL A
MOV R3, #0
MOV R1, #7
MOV R2, A
CALL ROTACIONAR
MOV A, R3
CALL CONVERTE
MOV P1,A
JMP $

ROTACIONAR:
 MOV A, R2
 RLC A
 JNC CONTA
 DEC R1
 MOV R2, A
 MOV A, R1
 JNZ ROTACIONAR

CONTA: INC R3
RET

CONVERTE: INC A
 MOVC A,@A+PC
 RET
TABELA: DB 40H, 79H, 24H, 30H, 19H, 12H, 02H, 78H, 00H, 10H, 08H, 03H, 46H, 21H, 06H, 0EH
END
